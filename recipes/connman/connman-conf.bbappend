# add some default configuration for connman on piA boards
# use DHCP on ethernet devices
FILESEXTRAPATHS_prepend := "${THISDIR}/connman-conf:"
