FILESEXTRAPATHS := "${THISDIR}/${PN}:"

#PRINC := "${@int(PRINC) + 10}"
