FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR_append = "-pia001"
#PRINC := "${@int(PRINC) + 10}"
