PR_append = ".pia002"

TARGET_CC_ARCH += "${LDFLAGS}"

