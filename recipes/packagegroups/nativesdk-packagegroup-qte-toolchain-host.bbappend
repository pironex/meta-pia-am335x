#PR_append = "+pia001"

RDEPENDS_${PN} += " nativesdk-dbus-c++ nativesdk-dbus-c++-dbg"
