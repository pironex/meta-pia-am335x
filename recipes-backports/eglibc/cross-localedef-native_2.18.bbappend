CFLAGS += "-fgnu89-inline"
