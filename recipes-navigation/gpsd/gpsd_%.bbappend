PACKAGECONFIG_remove = "qt"
