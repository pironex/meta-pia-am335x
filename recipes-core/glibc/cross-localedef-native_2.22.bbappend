FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

EGLIBCPATCHES += " file://0001-include-locale_t-compatibility-header.patch \
"
