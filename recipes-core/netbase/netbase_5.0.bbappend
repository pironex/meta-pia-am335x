THISDIR := "${@os.path.dirname(bb.data.getVar('FILE', d, True))}"
FILESPATH =. "${@base_set_filespath(["${THISDIR}/${PN}"], d)}:"

PACKAGE_ARCH_pia-am335x = "${MACHINE_ARCH}"
