FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://include_sysmacros_header.patch \
"