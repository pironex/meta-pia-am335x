do_deploy[prefuncs] += "package_get_auto_pr"
