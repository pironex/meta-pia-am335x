../../meta-arago/meta-arago-distro/classes/qt-vars.bbclass