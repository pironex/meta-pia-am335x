../../meta-arago/meta-arago-distro/classes/qt-provider.bbclass