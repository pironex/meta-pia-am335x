PACKAGECONFIG += "alsa pulseaudio gstreamer "