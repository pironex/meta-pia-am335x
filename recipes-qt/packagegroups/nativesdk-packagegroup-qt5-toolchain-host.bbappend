# -tools contains the real binaries, nativesdk-qttools is empty without dependency
RDEPENDS_${PN} += " \
    nativesdk-qttools-tools \
"
