RDEPENDS_${PN} += " \
    gpsd-dev \
    libmodbus-dev \
    libpcap-dev \
    libsocketcan-dev \
    libusb1-dev \
    mosquitto-dev \
"

RRECOMMENDS_${PN} += " \
"
