inherit update-alternatives

ALTERNATIVE_${PN} = "candump cansend"
ALTERNATIVE_PRIORITY = "200"
