FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://e2fsprogs-1.43-sysmacros.patch \
"