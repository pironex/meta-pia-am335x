RDEPENDS_${PN} += "python-subprocess"
