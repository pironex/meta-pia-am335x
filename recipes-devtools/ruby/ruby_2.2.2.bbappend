# fails to build static version with doc enabled
EXTRA_OECONF += "\
    --disable-install-doc \
"
