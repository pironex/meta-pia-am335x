SRCREV = "2cb6695e8dec00d887bdd5309d1b57d836fcd214"

LIC_FILES_CHKSUM = "file://mmc.c;beginline=1;endline=17;md5=f8b01ca0e7a359872d513a2d0bfd0d28"

PR_append = "+pia001"
