# morty default branch is for Kernel 4.9, we need the 4.4 version of the driver
#BRANCH = "ti-img-sgx/${PV}/k4.4"

#SRCREV = "fd47e44b18944cf7ade480ac67a9c0172619ff7e"